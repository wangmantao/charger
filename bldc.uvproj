# Keil uVision project bldc.uvproj, settings and files
target BLDC (MCS-51)
  device: N76E003 Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x47FF)  XRAM(0 - 0x2FF) CLOCK(16000000)
  output: bldc +hex
  c flags: Optimize=8 SizeSpeed=1
  c define: FOSC_160000
  c include: .\Libs\Include
  group Source
    ./Code/: main.c
  group comm
    ./Libs/Common/: Common.c Delay.c
